# Keil uVision project Ethernet.uvproj, settings and files
target Target 1 (MCS-51)
  device: T8xC5121 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(16000000) MODP2
  output: Ethernet_uv4 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\app;.\bsp;.\uip
  group uip
    ./uip/: uip.c uip.h uip_arch.c uip_arch.h uip_arp.c uip_arp.h uipopt.h
  group app
    ./app/: app.c app.h main.c main.h
  group bsp
    ./uip/: etherdev.h etherdev.c
    ./bsp/: mytype.h STC12C5A60S2.H uart.c uart.h adc.c adc.h
