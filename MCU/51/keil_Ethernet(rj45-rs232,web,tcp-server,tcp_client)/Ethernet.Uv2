### uVision2 Project, (C) Keil Software
### Do not modify !

Target (app), 0x0000 // Tools: 'MCS-51'

Group (bsp)
Group (app)
Group (uip)

File 1,5,<.\bsp\mytype.h><mytype.h> 0x0 
File 1,5,<.\bsp\STC12C5A60S2.H><STC12C5A60S2.H> 0x0 
File 1,1,<.\bsp\uart.c><uart.c> 0x0 
File 1,5,<.\bsp\uart.h><uart.h> 0x0 
File 1,1,<.\bsp\adc.c><adc.c> 0x0 
File 2,1,<.\app\app.c><app.c> 0x0 
File 2,5,<.\app\app.h><app.h> 0x0 
File 2,1,<.\app\main.c><main.c> 0x0 
File 2,5,<.\app\main.h><main.h> 0x0 
File 3,1,<.\uip\uip.c><uip.c> 0x0 
File 3,5,<.\uip\uip.h><uip.h> 0x0 
File 3,1,<.\uip\uip_arch.c><uip_arch.c> 0x0 
File 3,5,<.\uip\uip_arch.h><uip_arch.h> 0x0 
File 3,1,<.\uip\uip_arp.c><uip_arp.c> 0x0 
File 3,5,<.\uip\uip_arp.h><uip_arp.h> 0x0 
File 3,5,<.\uip\uipopt.h><uipopt.h> 0x0 
File 3,1,<.\uip\etherdev.c><etherdev.c> 0x0 
File 3,5,<.\uip\etherdev.h><etherdev.h> 0x0 


Options 1,0,0  // Target 'app'
 Device (T89C51AC2)
 Vendor (Atmel)
 Cpu (IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0-0x3FF) CLOCK(40000000) MODP2)
 FlashUt ()
 StupF ("LIB\STARTUP.A51" ("Standard 8051 Startup Code"))
 FlashDR ()
 Rgf (89c51ac2.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ÿAtmelWM\)
 OrgReg (ÿAtmelWM\)
 TgStat=0
 OutDir (.\out\)
 OutName (Ethernet_uv2)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\out\)
 HexSel=0
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 SVCSID <>
 MODEL5=0
 RTOS5=0
 ROMSZ5=2
 DHOLD5=0
 XHOLD5=0
 T51FL=624
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,0,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 1,0,0,0,0,0,128,0,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,0,0,0,0,4,0,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=21630224
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 (.\app\;.\bsp\;.\uip\)
 AX51FL=4
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=292
 LX51OVL ()
 LX51MSC ()
 LX51DWN ()
 LX51LFI ()
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL ()
 LX51CSC ()
 LX51UCS ()
 LX51COB ()
 LX51XDB ()
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)()(DP51.DLL)(-p51AC2)(S8051.DLL)()(TP51.DLL)(-p51AC2)
  OPTDBG 509,0,()()()()()()()()()() ()()()()
 FLASH1 { 1,0,0,0,0,0,0,0,255,255,255,255,0,0,0,0,0,0,0,0 }
 FLASH2 ()
 FLASH3 ()
EndOpt

